## sdkconfig.defaults
```kconfig
CONFIG_VITTIL_PROJECT_KEY="ecr_your_project_key"
CONFIG_ESP_COREDUMP_ENABLE_TO_FLASH=y
```
